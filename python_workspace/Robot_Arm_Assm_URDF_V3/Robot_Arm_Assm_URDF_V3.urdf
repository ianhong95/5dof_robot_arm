Commit message: Fixed error in kinematics

File: python_workspace/Robot_Arm_Assm_URDF_V3/Robot_Arm_Assm_URDF_V3.urdf (robot description, URDF)
Before this commit: robot Robot_Arm_Assm_URDF_V3, 6 links, 5 joints
Joints:
- joint J4: origin xyz=0 0.07 0 rpy=1.5708 0 0 -> xyz=0 0.085 0 rpy=1.5708 0 0
